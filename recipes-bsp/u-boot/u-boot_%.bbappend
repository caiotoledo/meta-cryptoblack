FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://uEnv.txt "
UBOOT_ENV = "uEnv"
